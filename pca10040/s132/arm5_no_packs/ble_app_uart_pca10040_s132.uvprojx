# Keil uVision project ble_app_uart_pca10040_s132.uvprojx, settings and files
target nrf52832_xxaa (5050106::V5.05 update 1 (build 106)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.14.1
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: nrf52832_xxaa +hex
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: BOARD_PCA10040 CONFIG_GPIO_AS_PINRESET NRF52 NRF52832_XXAA NRF52_PAN_74 NRF_SD_BLE_API_VERSION=5 S132 SOFTDEVICE_PRESENT SWI_DISABLE0
  c misc: --reduce_paths
  c include: ..\..\..\config;..\..\..\external\SDK\components;..\..\..\external\SDK\components\ble\ble_advertising;..\..\..\external\SDK\components\ble\ble_dtm;..\..\..\external\SDK\components\ble\ble_racp;..\..\..\external\SDK\components\ble\ble_services\ble_ancs_c;..\..\..\external\SDK\components\ble\ble_services\ble_ans_c;..\..\..\external\SDK\components\ble\ble_services\ble_bas;..\..\..\external\SDK\components\ble\ble_services\ble_bas_c;..\..\..\external\SDK\components\ble\ble_services\ble_cscs;..\..\..\external\SDK\components\ble\ble_services\ble_cts_c;..\..\..\external\SDK\components\ble\ble_services\ble_dfu;..\..\..\external\SDK\components\ble\ble_services\ble_dis;..\..\..\external\SDK\components\ble\ble_services\ble_gls;..\..\..\external\SDK\components\ble\ble_services\ble_hids;..\..\..\external\SDK\components\ble\ble_services\ble_hrs;..\..\..\external\SDK\components\ble\ble_services\ble_hrs_c;..\..\..\external\SDK\components\ble\ble_services\ble_hts;..\..\..\external\SDK\components\ble\ble_services\ble_ias;..\..\..\external\SDK\components\ble\ble_services\ble_ias_c;..\..\..\external\SDK\components\ble\ble_services\ble_lbs;..\..\..\external\SDK\components\ble\ble_services\ble_lbs_c;..\..\..\external\SDK\components\ble\ble_services\ble_lls;..\..\..\external\SDK\components\ble\ble_services\ble_nus;..\..\..\external\SDK\components\ble\ble_services\ble_nus_c;..\..\..\external\SDK\components\ble\ble_services\ble_rscs;..\..\..\external\SDK\components\ble\ble_services\ble_rscs_c;..\..\..\external\SDK\components\ble\ble_services\ble_tps;..\..\..\external\SDK\components\ble\common;..\..\..\external\SDK\components\ble\nrf_ble_gatt;..\..\..\external\SDK\components\ble\nrf_ble_qwr;..\..\..\external\SDK\components\ble\peer_manager;..\..\..\external\SDK\components\boards;..\..\..\external\SDK\components\drivers_nrf\clock;..\..\..\external\SDK\components\drivers_nrf\common;..\..\..\external\SDK\components\drivers_nrf\comp;..\..\..\external\SDK\components\drivers_nrf\delay;..\..\..\external\SDK\components\drivers_nrf\gpiote;..\..\..\external\SDK\components\drivers_nrf\hal;..\..\..\external\SDK\components\drivers_nrf\i2s;..\..\..\external\SDK\components\drivers_nrf\lpcomp;..\..\..\external\SDK\components\drivers_nrf\pdm;..\..\..\external\SDK\components\drivers_nrf\power;..\..\..\external\SDK\components\drivers_nrf\ppi;..\..\..\external\SDK\components\drivers_nrf\pwm;..\..\..\external\SDK\components\drivers_nrf\qdec;..\..\..\external\SDK\components\drivers_nrf\rng;..\..\..\external\SDK\components\drivers_nrf\rtc;..\..\..\external\SDK\components\drivers_nrf\saadc;..\..\..\external\SDK\components\drivers_nrf\spi_master;..\..\..\external\SDK\components\drivers_nrf\spi_slave;..\..\..\external\SDK\components\drivers_nrf\swi;..\..\..\external\SDK\components\drivers_nrf\timer;..\..\..\external\SDK\components\drivers_nrf\twi_master;..\..\..\external\SDK\components\drivers_nrf\twis_slave;..\..\..\external\SDK\components\drivers_nrf\uart;..\..\..\external\SDK\components\drivers_nrf\usbd;..\..\..\external\SDK\components\drivers_nrf\wdt;..\..\..\external\SDK\components\libraries\atomic;..\..\..\external\SDK\components\libraries\atomic_fifo;..\..\..\external\SDK\components\libraries\balloc;..\..\..\external\SDK\components\libraries\bsp;..\..\..\external\SDK\components\libraries\button;..\..\..\external\SDK\components\libraries\crc16;..\..\..\external\SDK\components\libraries\crc32;..\..\..\external\SDK\components\libraries\csense;..\..\..\external\SDK\components\libraries\csense_drv;..\..\..\external\SDK\components\libraries\ecc;..\..\..\external\SDK\components\libraries\experimental_cli;..\..\..\external\SDK\components\libraries\experimental_log;..\..\..\external\SDK\components\libraries\experimental_log\src;..\..\..\external\SDK\components\libraries\experimental_memobj;..\..\..\external\SDK\components\libraries\experimental_section_vars;..\..\..\external\SDK\components\libraries\fds;..\..\..\external\SDK\components\libraries\fifo;..\..\..\external\SDK\components\libraries\fstorage;..\..\..\external\SDK\components\libraries\gpiote;..\..\..\external\SDK\components\libraries\hardfault;..\..\..\external\SDK\components\libraries\hci;..\..\..\external\SDK\components\libraries\led_softblink;..\..\..\external\SDK\components\libraries\low_power_pwm;..\..\..\external\SDK\components\libraries\mem_manager;..\..\..\external\SDK\components\libraries\mutex;..\..\..\external\SDK\components\libraries\pwm;..\..\..\external\SDK\components\libraries\pwr_mgmt;..\..\..\external\SDK\components\libraries\queue;..\..\..\external\SDK\components\libraries\scheduler;..\..\..\external\SDK\components\libraries\slip;..\..\..\external\SDK\components\libraries\strerror;..\..\..\external\SDK\components\libraries\timer;..\..\..\external\SDK\components\libraries\twi;..\..\..\external\SDK\components\libraries\uart;..\..\..\external\SDK\components\libraries\usbd;..\..\..\external\SDK\components\libraries\usbd\class\audio;..\..\..\external\SDK\components\libraries\usbd\class\cdc;..\..\..\external\SDK\components\libraries\usbd\class\cdc\acm;..\..\..\external\SDK\components\libraries\usbd\class\hid;..\..\..\external\SDK\components\libraries\usbd\class\hid\generic;..\..\..\external\SDK\components\libraries\usbd\class\hid\kbd;..\..\..\external\SDK\components\libraries\usbd\class\hid\mouse;..\..\..\external\SDK\components\libraries\usbd\class\msc;..\..\..\external\SDK\components\libraries\usbd\config;..\..\..\external\SDK\components\libraries\util;..\..\..\external\SDK\components\softdevice\common;..\..\..\external\SDK\components\softdevice\s132\headers;..\..\..\external\SDK\components\softdevice\s132\headers\nrf52;..\..\..\external\SDK\components\toolchain;..\..\..\external\SDK\external\fprintf;..\..\..\external\SDK\external\segger_rtt;..\config;..\..\..\mqtt-sn\mqtt_sn_client;..\..\..\mqtt-sn\paho
  asm define: as above
  asm misc: --cpreproc_opts=-DBOARD_PCA10040,-DCONFIG_GPIO_AS_PINRESET,-DNRF52,-DNRF52832_XXAA,-DNRF52_PAN_74,-DNRF_SD_BLE_API_VERSION=5,-DS132,-DSOFTDEVICE_PRESENT,-DSWI_DISABLE0
  asm include: ..\..\..\config;..\..\..\external\SDK\components;..\..\..\external\SDK\components\ble\ble_advertising;..\..\..\external\SDK\components\ble\ble_dtm;..\..\..\external\SDK\components\ble\ble_racp;..\..\..\external\SDK\components\ble\ble_services\ble_ancs_c;..\..\..\external\SDK\components\ble\ble_services\ble_ans_c;..\..\..\external\SDK\components\ble\ble_services\ble_bas;..\..\..\external\SDK\components\ble\ble_services\ble_bas_c;..\..\..\external\SDK\components\ble\ble_services\ble_cscs;..\..\..\external\SDK\components\ble\ble_services\ble_cts_c;..\..\..\external\SDK\components\ble\ble_services\ble_dfu;..\..\..\external\SDK\components\ble\ble_services\ble_dis;..\..\..\external\SDK\components\ble\ble_services\ble_gls;..\..\..\external\SDK\components\ble\ble_services\ble_hids;..\..\..\external\SDK\components\ble\ble_services\ble_hrs;..\..\..\external\SDK\components\ble\ble_services\ble_hrs_c;..\..\..\external\SDK\components\ble\ble_services\ble_hts;..\..\..\external\SDK\components\ble\ble_services\ble_ias;..\..\..\external\SDK\components\ble\ble_services\ble_ias_c;..\..\..\external\SDK\components\ble\ble_services\ble_lbs;..\..\..\external\SDK\components\ble\ble_services\ble_lbs_c;..\..\..\external\SDK\components\ble\ble_services\ble_lls;..\..\..\external\SDK\components\ble\ble_services\ble_nus;..\..\..\external\SDK\components\ble\ble_services\ble_nus_c;..\..\..\external\SDK\components\ble\ble_services\ble_rscs;..\..\..\external\SDK\components\ble\ble_services\ble_rscs_c;..\..\..\external\SDK\components\ble\ble_services\ble_tps;..\..\..\external\SDK\components\ble\common;..\..\..\external\SDK\components\ble\nrf_ble_gatt;..\..\..\external\SDK\components\ble\nrf_ble_qwr;..\..\..\external\SDK\components\ble\peer_manager;..\..\..\external\SDK\components\boards;..\..\..\external\SDK\components\drivers_nrf\clock;..\..\..\external\SDK\components\drivers_nrf\common;..\..\..\external\SDK\components\drivers_nrf\comp;..\..\..\external\SDK\components\drivers_nrf\delay;..\..\..\external\SDK\components\drivers_nrf\gpiote;..\..\..\external\SDK\components\drivers_nrf\hal;..\..\..\external\SDK\components\drivers_nrf\i2s;..\..\..\external\SDK\components\drivers_nrf\lpcomp;..\..\..\external\SDK\components\drivers_nrf\pdm;..\..\..\external\SDK\components\drivers_nrf\power;..\..\..\external\SDK\components\drivers_nrf\ppi;..\..\..\external\SDK\components\drivers_nrf\pwm;..\..\..\external\SDK\components\drivers_nrf\qdec;..\..\..\external\SDK\components\drivers_nrf\rng;..\..\..\external\SDK\components\drivers_nrf\rtc;..\..\..\external\SDK\components\drivers_nrf\saadc;..\..\..\external\SDK\components\drivers_nrf\spi_master;..\..\..\external\SDK\components\drivers_nrf\spi_slave;..\..\..\external\SDK\components\drivers_nrf\swi;..\..\..\external\SDK\components\drivers_nrf\timer;..\..\..\external\SDK\components\drivers_nrf\twi_master;..\..\..\external\SDK\components\drivers_nrf\twis_slave;..\..\..\external\SDK\components\drivers_nrf\uart;..\..\..\external\SDK\components\drivers_nrf\usbd;..\..\..\external\SDK\components\drivers_nrf\wdt;..\..\..\external\SDK\components\libraries\atomic;..\..\..\external\SDK\components\libraries\atomic_fifo;..\..\..\external\SDK\components\libraries\balloc;..\..\..\external\SDK\components\libraries\bsp;..\..\..\external\SDK\components\libraries\button;..\..\..\external\SDK\components\libraries\crc16;..\..\..\external\SDK\components\libraries\crc32;..\..\..\external\SDK\components\libraries\csense;..\..\..\external\SDK\components\libraries\csense_drv;..\..\..\external\SDK\components\libraries\ecc;..\..\..\external\SDK\components\libraries\experimental_cli;..\..\..\external\SDK\components\libraries\experimental_log;..\..\..\external\SDK\components\libraries\experimental_log\src;..\..\..\external\SDK\components\libraries\experimental_memobj;..\..\..\external\SDK\components\libraries\experimental_section_vars;..\..\..\external\SDK\components\libraries\fds;..\..\..\external\SDK\components\libraries\fifo;..\..\..\external\SDK\components\libraries\fstorage;..\..\..\external\SDK\components\libraries\gpiote;..\..\..\external\SDK\components\libraries\hardfault;..\..\..\external\SDK\components\libraries\hci;..\..\..\external\SDK\components\libraries\led_softblink;..\..\..\external\SDK\components\libraries\low_power_pwm;..\..\..\external\SDK\components\libraries\mem_manager;..\..\..\external\SDK\components\libraries\mutex;..\..\..\external\SDK\components\libraries\pwm;..\..\..\external\SDK\components\libraries\pwr_mgmt;..\..\..\external\SDK\components\libraries\queue;..\..\..\external\SDK\components\libraries\scheduler;..\..\..\external\SDK\components\libraries\slip;..\..\..\external\SDK\components\libraries\strerror;..\..\..\external\SDK\components\libraries\timer;..\..\..\external\SDK\components\libraries\twi;..\..\..\external\SDK\components\libraries\uart;..\..\..\external\SDK\components\libraries\usbd;..\..\..\external\SDK\components\libraries\usbd\class\audio;..\..\..\external\SDK\components\libraries\usbd\class\cdc;..\..\..\external\SDK\components\libraries\usbd\class\cdc\acm;..\..\..\external\SDK\components\libraries\usbd\class\hid;..\..\..\external\SDK\components\libraries\usbd\class\hid\generic;..\..\..\external\SDK\components\libraries\usbd\class\hid\kbd;..\..\..\external\SDK\components\libraries\usbd\class\hid\mouse;..\..\..\external\SDK\components\libraries\usbd\class\msc;..\..\..\external\SDK\components\libraries\usbd\config;..\..\..\external\SDK\components\libraries\util;..\..\..\external\SDK\components\softdevice\common;..\..\..\external\SDK\components\softdevice\s140\headers;..\..\..\external\SDK\components\softdevice\s140\headers\nrf52;..\..\..\external\SDK\components\toolchain;..\..\..\external\SDK\external\fprintf;..\..\..\external\SDK\external\segger_rtt;..\config
  library: MicroLIB
  memory RVCT4: ROM 0x23000 size 0x5d000
  memory RVCT9: RAM 0x20002a68 size 0xd598
  link misc: --diag_suppress 6330
  group Application
    ../../../: main.c
    ../config/: sdk_config.h
  group Board Definition
    ../../../external/SDK/components/boards/: boards.c
  group Board Support
    ../../../external/SDK/components/libraries/bsp/: bsp.c bsp_btn_ble.c bsp_nfc.c
  group nRF_BLE
    ../../../external/SDK/components/ble/common/: ble_advdata.c ble_conn_params.c ble_conn_state.c ble_srv_common.c
    ../../../external/SDK/components/ble/ble_advertising/: ble_advertising.c
    ../../../external/SDK/components/ble/nrf_ble_gatt/: nrf_ble_gatt.c
  group nRF_BLE_Services
    ../../../external/SDK/components/ble/ble_services/ble_nus/: ble_nus.c
  group nRF_Drivers
    ../../../external/SDK/components/drivers_nrf/clock/: nrf_drv_clock.c
    ../../../external/SDK/components/drivers_nrf/common/: nrf_drv_common.c
    ../../../external/SDK/components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../../../external/SDK/components/drivers_nrf/uart/: nrf_drv_uart.c
    ../../../external/SDK/components/drivers_nrf/rng/: nrf_drv_rng.c
  group nRF_Libraries
    ../../../external/SDK/components/libraries/button/: app_button.c
    ../../../external/SDK/components/libraries/util/: app_error.c app_error_weak.c app_util_platform.c nrf_assert.c sdk_mapped_flags.c
    ../../../external/SDK/components/libraries/fifo/: app_fifo.c
    ../../../external/SDK/components/libraries/scheduler/: app_scheduler.c
    ../../../external/SDK/components/libraries/timer/: app_timer.c
    ../../../external/SDK/components/libraries/uart/: app_uart_fifo.c retarget.c
    ../../../external/SDK/components/libraries/hardfault/: hardfault_implementation.c
    ../../../external/SDK/components/libraries/atomic_fifo/: nrf_atfifo.c
    ../../../external/SDK/components/libraries/balloc/: nrf_balloc.c
    ../../../external/SDK/external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ../../../external/SDK/components/libraries/fstorage/: nrf_fstorage.c nrf_fstorage_sd.c
    ../../../external/SDK/components/libraries/experimental_memobj/: nrf_memobj.c
    ../../../external/SDK/components/libraries/pwr_mgmt/: nrf_pwr_mgmt.c
    ../../../external/SDK/components/libraries/experimental_section_vars/: nrf_section_iter.c
    ../../../external/SDK/components/libraries/strerror/: nrf_strerror.c
    C:/SDK/nRF5_SDK_14.0.0_3bcc1f7/components/libraries/mem_manager/: mem_manager.c
    ../../../external/SDK/components/libraries/queue/: nrf_queue.c
  group nRF_Log
    ../../../external/SDK/components/libraries/experimental_log/src/: nrf_log_backend_rtt.c nrf_log_backend_serial.c nrf_log_default_backends.c nrf_log_frontend.c nrf_log_str_formatter.c
  group nRF_Segger_RTT
    ../../../external/SDK/external/segger_rtt/: RTT_Syscalls_KEIL.c SEGGER_RTT.c SEGGER_RTT_printf.c
  group nRF_SoftDevice
    ../../../external/SDK/components/softdevice/common/: nrf_sdh.c nrf_sdh_ble.c nrf_sdh_soc.c
  group MQTT-SN_Paho
    ../../../mqtt-sn/paho/: MQTTSNConnectClient.c MQTTSNConnectServer.c MQTTSNDeserializePublish.c MQTTSNPacket.c MQTTSNSearchClient.c MQTTSNSearchServer.c MQTTSNSerializePublish.c MQTTSNSubscribeClient.c MQTTSNSubscribeServer.c MQTTSNUnsubscribeClient.c MQTTSNUnsubscribeServer.c
  group MQTT-SN
    ../../../mqtt-sn/mqtt_sn_client/: mqttsn_client.c mqttsn_packet_fifo.c mqttsn_packet_receiver.c mqttsn_packet_sender.c mqttsn_platform.c
target flash_s132_nrf52_5.0.0_softdevice (ARM-ADS)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.14.1
  cpu: as above
  output: s132_nrf52_5.0.0_softdevice.hex +hex
  c flags: Optim=4 OneElfS=1 uC99=1
  c misc: --reduce_paths
  c include: ..\..\..\config;..\config
  asm misc: --cpreproc_opts=
  asm include: ..\..\..\config;..\config
  library: MicroLIB
  memory RVCT4: ROM 0x23000 size 0x5d000
  memory RVCT9: RAM 0x20002a68 size 0xd598
  link misc: --diag_suppress 6330
software components: CMSIS:CORE 4.3.0, Device:Startup 8.14.1
